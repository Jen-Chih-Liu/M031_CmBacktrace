# Keil uVision project Hard_Fault_Sample.uvproj, settings and files
target Hard_Fault_Sample (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Hard_Fault_Sample +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\cm_backtrace
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
    ../cm_backtrace/: cm_backtrace.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
